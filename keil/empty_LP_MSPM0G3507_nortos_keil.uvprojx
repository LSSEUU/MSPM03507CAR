# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ../include,../Source,../Hardware,../System,../Control,../App,../Config,../include/ti/devices/msp,../include/ti/driverlib,../include/ti/driverlib/m0p,../include/third_party/CMSIS/Core/Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1f800
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../lib/driverlib.a
  group Source
    ../Source/: main.c board.c startup_mspm0g350x_uvision.s ti_msp_dl_config.h ti_msp_dl_config.c
  group Driverlib
    ../lib/: driverlib.a
  group Hardware
    ../Hardware/: uart_debug.c vision_uart.c zdt_stepper_uart.c zdt_stepper.c led.c key.c buzzer.c oled.c motor.c encoder.c grayscale.c gyro.c watchdog.c ir_nec.c ir_event_queue.c ir_receiver.c
  group System
    ../System/: reset_diag.c diagnostics_health.c diagnostics.c system_time.c scheduler.c system_state.c safety.c control_params.c parameter_store.c grayscale_calibration.c lever_calibration.c lever_actuator.c control_protocol.c m6_wire.c m6_link.c m6_rpc.c zdt_stepper_test.c m6_vision_uart.c m6_action_validate.c control_runtime.c m6_telemetry.c line_trace.c
  group Control
    ../Control/: pid.c filter.c wheel_speed.c heading.c line_follow.c line_yaw_assist.c h_course_profile.c
  group App
    ../App/: app_line.c app_h2_panel.c h_mission.c h2_control_profile.c h_mission_control_profile.c app_remote.c app_manual_drive.c
